Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Accessories_Ceramica-Catalano_Green-Frame-80.ifc
Time: 2022-10-19T16:59:30
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Green Frame 80
ePset_BIMobjectScript - LEGS: WITH; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Green Frame 80; SKU (BO_prodsku): green-frame-80-5ST80GRNS; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Frames; ProductGroup (BO_prodgroup): Green; EditionNumber (BO_edinum): 1; Width (BO_width): 750; Height (BO_height): 350; Depth (BO_depth): 430; Weight (BO_weight): 11; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/green-frame-80-5ST80GRNS; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/green-frame-80-5ST80GRNS; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-accessories1; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
